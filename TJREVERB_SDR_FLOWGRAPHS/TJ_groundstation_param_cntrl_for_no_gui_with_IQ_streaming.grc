<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>TJ_groundstation_param_cntrl_for_no_gui_with_IQ_streaming</value></param>
<param><key>author</key><value>Thomas Jefferson High School</value></param>
<param><key>description</key><value>TJ Reverb AFSK Modem</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>TJ Groundstation Parameter Control (no GUI with IQ Streaming)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>audio_line_driver</value></param>
<param><key>value</key><value>0.8</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>audio line driver</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.01</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>freq_chooser</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100e6</value></param>
<param><key>step</key><value>100e3</value></param>
<param><key>stop</key><value>6e9</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>freq_chooser</value></param>
<param><key>value</key><value>144.39e6</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label0</key><value>APRS (144.39MHz)</value></param>
<param><key>label1</key><value>NOAA-15 (137.62MHz)</value></param>
<param><key>label2</key><value>NOAA-18 (137.9125MHz)</value></param>
<param><key>label3</key><value>NOAA-19 (137.1MHz)</value></param>
<param><key>label4</key><value>FM (88.5MHz)</value></param>
<param><key>label</key><value>APRS/NOAA Satellite Frequencies</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>144.39e6</value></param>
<param><key>option1</key><value>137.62e6</value></param>
<param><key>option2</key><value>137.9125e6</value></param>
<param><key>option3</key><value>137.1e6</value></param>
<param><key>option4</key><value>88.5e6</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>"rx gain"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>89</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>groundstation_ip_addr</value></param>
<param><key>comment</key><value>this should be the IP address of the cubesat's
network-facing IP interface
only use 'localhost' if testing controller
flowgraph on same machine</value></param>
<param><key>value</key><value>"192.168.1.10"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>groundstation_zmq_port_1</value></param>
<param><key>comment</key><value>use port value 5500-5599</value></param>
<param><key>value</key><value>"5501"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>groundstation_zmq_port_2</value></param>
<param><key>comment</key><value>use port value 5500-5599</value></param>
<param><key>value</key><value>"5502"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>groundstation_zmq_port_3</value></param>
<param><key>comment</key><value>use port value 5500-5599</value></param>
<param><key>value</key><value>"5503"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>groundstation_zmq_port_4</value></param>
<param><key>comment</key><value>use port value 5500-5599</value></param>
<param><key>value</key><value>"5504"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_rx_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>tx gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>89</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xml_rpc_port</value></param>
<param><key>value</key><value>5550</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>hw:1,0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>rf_rx_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tabs@0:0,1,1,1</value></param>
<param><key>name</key><value>"GROUNDSTATION MOD"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1_1_0</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0:2,1,1,1</value></param>
<param><key>name</key><value>"GROUNDSTATION DEMOD"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>tabs@3:0,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"GROUNDSTATION AUDIO MOD"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>audio_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_2</value></param>
<param><key>gui_hint</key><value>tabs@3:1,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"GROUNDSTATION AUDIO DEMOD"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>audio_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0:1,1,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_2_0</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0:3,1,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label0</key><value>Big Picture</value></param>
<param><key>label1</key><value>CUBESAT TX/RX</value></param>
<param><key>label2</key><value>GND STAT TX/RX</value></param>
<param><key>label3</key><value>MOD/DEMOD</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client1_0_0_0_0</value></param>
<param><key>addr</key><value>cubesat_ip_addr</value></param>
<param><key>callback</key><value>set_audio_line_driver</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>variable</key><value>audio_line_driver</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client1_0_0_1</value></param>
<param><key>addr</key><value>cubesat_ip_addr</value></param>
<param><key>callback</key><value>set_freq</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>variable</key><value>freq</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client1_0_1</value></param>
<param><key>addr</key><value>cubesat_ip_addr</value></param>
<param><key>callback</key><value>set_tx_gain</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>variable</key><value>tx_gain</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client1_1</value></param>
<param><key>addr</key><value>cubesat_ip_addr</value></param>
<param><key>callback</key><value>set_gain</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>variable</key><value>gain</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>"tcp://"+groundstation_ip_addr+":"+groundstation_zmq_port_1</value></param>
<param><key>comment</key><value>stand-in for downsampled signal
(output of LPF)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0_0</value></param>
<param><key>address</key><value>"tcp://"+groundstation_ip_addr+":"+groundstation_zmq_port_2</value></param>
<param><key>comment</key><value>stand in for upsampled signal 
(output of rational resampler)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0_0_0</value></param>
<param><key>address</key><value>"tcp://"+groundstation_ip_addr+":"+groundstation_zmq_port_3</value></param>
<param><key>comment</key><value>stand-in for NBFM output</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0_0_0_0</value></param>
<param><key>address</key><value>"tcp://"+groundstation_ip_addr+":"+groundstation_zmq_port_4</value></param>
<param><key>comment</key><value>stand in for AFSK modulator</value></param>
<param><key>type</key><value>float</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
